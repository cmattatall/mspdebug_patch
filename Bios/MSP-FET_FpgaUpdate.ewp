# IAR project MSP-FET_FpgaUpdate.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F6638 MSP430F6638
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP_FET
  ICC430.newCCIncludePaths: src\fpga_update; src\fpga_update\DirectC; src\hil\msp_fet; include; src\hil
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  postbuild: tools\convertEzFetTxt.bat $PROJ_DIR$ MSP_FetFpgaHal
  XLINK.XclFile: config\hal_lnk430F6638fpga.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    src/fpga_update/: cstartup_FpgaUpdate.s43 FpgaBitstream.h FpgaUpdate.c
  group config
    config/: hal_lnk430F6638.xcl hal_lnk430F6638fpga.xcl
  group DirectC
    src/fpga_update/DirectC/: dpalg.c dpchain.c dpcom.c dpcore.c dpdef.h dpfrom.c dpjtag.c dpnvm.c dpsecurity.c dpuser.c dpuser.h dputil.c dputil.h
